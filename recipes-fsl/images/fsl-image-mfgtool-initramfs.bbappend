IMAGE_INSTALL_remove = " ax-info sys-led gstreamer1.0-plugins-imx \
                         ftpd xinetd netkit-telnet quectel-cm modemmanager \
                         stress-ng libaxeapi libaxeapi-dev axeapi \
"
