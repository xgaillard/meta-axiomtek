PLATFORM_FLAVOR_rbox630-6dl     = "mx6dlsabresd"
